# Repository unioncyclist/PT4123_Led_Driver

File README.md:

# PT4123_Led_Driver
Adjustable Constant current LED driver using the PT4123

## Schematics

## PCB

## Setting Output

Max output current is set by 0.2/R4. Here R4=75mA, so the max output is 2.67A if following the BOM

DO NOT test the circuit without any LED connected to the output, possible damage to the chip

## Control

Method1. The R2 can be replaces by a variable resistor, no need for the control pin

Method2. Input DC voltage source 0-2.5v, no need for R2

Method3. Input PWM 0-3.3v, no need for R2

## Finished prototype

-the TVS protection at the input is optional

## Special thanks

This prototype used Kicad(https://github.com/kicad), thanks to the contributers of the project

## KiCad design led_driver.kicad_pcb

Parts:
C2, C3: 10uf; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C7: 1uf; R_0603_1608Metric
C8: 100nf; R_0603_1608Metric
D1: LED; R_0603_1608Metric
D2: SMBJ20A; D_SMB
D4: D_Schottky; D_SMA_Handsoldering
F1: 60V/0.75A; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
H1, H2, H3, H4: MountingHole; ToolingHole_1.152mm
J1: Conn_01x02_Pin; AMASS_XT30U-F_1x02_P5.0mm_Vertical
J2: Conn_01x01_Pin; PinHeader_1x01_P2.54mm_Vertical
L3: 22uH; L_Chilisin_BMRF00101040
LED1: Conn_01x02_Pin; AMASS_XT30U-F_1x02_P5.0mm_Vertical
R2: 100k; R_0603_1608Metric
R4: 75mR; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R5: 4.7k; R_0603_1608Metric
U3: PT4123EEESH; Diodes_SO-8EP

Connections:
/Control1: J2.1 (Pin_1_1), R2.1, U3.1 (DIM)
/VIN: C2.2, C3.2, D2.1 (A1), D4.1 (K), F1.2, R4.1, R5.1, U3.2 (VIN)
GND: C2.1, C3.1, C7.2, D1.1 (K), D2.2 (A2), J1.1, R2.2, U3.7 (GND), U3.8 (GND)
unnamed: D1.2 (A), R5.2
unnamed: D4.2 (A), L3.1, U3.5 (SW), U3.6 (SW), U3.9 (SW)
unnamed: F1.1, J1.2
unnamed: C8.2, L3.2, LED1.1
unnamed: C8.1, LED1.2, R4.2, U3.3 (CSN)
unnamed: C7.1, U3.4 (VCC)

Notes on the sheet:
PWM Control Input
下拉100k测试用，一半亮度。接入pwm调光后最好拆掉
LED Control
Power Input 12V (6-20V)

Board: 2 copper layers, 46.5 x 22.0 mm, 20 parts (0 on the bottom side), 9 nets.

## Commit log

2026-06-05 Kicad schematics and PCB
